# IAR project STM32F302R8-Nucleo.ewp, settings and files
configuration STM32F302R8-Nucleo (ARM, debug)
  General.OGChipSelectEditMenu: STM32F302R8 ST STM32F302R8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F302x8
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\Middlewares\ST\MC_6Step_Lib\Inc; ..\..\..\..\..\..\Middlewares\ST\UART_serial_com\Inc; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IHM07M1; ..\..\..\..\..\..\Drivers\BSP\Components\l6230; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include; ..\..\..\..\..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F3xx-Nucleo
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: X-CUBE-SPN7.bin
  ILINK.IlinkOutputFile: STM32F302R8-Nucleo Configuration.out
  ILINK.IlinkIcfFile: stm32f302x8_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32F302R8-Nucleo - DEMO mode (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.FPU2: 8
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F302x8; DEMOMODE
  OBJCOPY.OOCOutputFile: STM32F302R8-Nucleo.hex
configuration STM32F302R8-Nucleo - COMM mode (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.FPU2: 8
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F302x8; UART_COMM
  OBJCOPY.OOCOutputFile: X-CUBE-SPN7-LIB-STM32F302R8-Nucleo.hex
configuration STM32F302R8-Nucleo - BOOT mode (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.FPU2: 8
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F302x8; BOOT
  OBJCOPY.OOCOutputFile: MCKIT-STM32F302R8-Nucleo6step.hex
  ILINK.IlinkIcfFile: stm32f302_flash_relocated6STEP.icf
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/l6230/: l6230.c
  group Drivers/BSP/STM32F3xx-Nucleo
    ../../../../../../Drivers/BSP/STM32F3xx-Nucleo/: stm32f3xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-IHM07M1
    ../../../../../../Drivers/BSP/X-NUCLEO-IHM07M1/: X-NUCLEO-IHM07M1.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../../../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dac.c stm32f3xx_hal_dac_ex.c stm32f3xx_hal_dma.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_usart.c
    ../../Src/: stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c
  group Example/EWARM
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/iar/: startup_stm32f302x8.s
  group Example/User
    ../../Src/: main_F302.c stm32F302_nucleo_ihm07m1.c stm32f3xx_hal_msp.c stm32f3xx_it.c
    ../../Inc/: MC_SixStep_param.h
  group Middlewares/MC 6Step Lib
    ../../../../../../Middlewares/ST/MC_6Step_Lib/Src/: 6Step_Lib.c
  group Middlewares/UART serial com
    ../../../../../../Middlewares/ST/UART_serial_com/Src/: UART_UI.c
